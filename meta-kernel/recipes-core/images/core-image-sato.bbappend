IMAGE_INSTALL:append = " ball-detect v4l-utils kernel-modules linux-firmware python3-opencv python3-numpy python3-pyqt5"


